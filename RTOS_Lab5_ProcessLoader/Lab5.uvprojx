# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR LAB5
  c include: ..;..\..\..;..\..\lab
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab5.def
  group Source
    ./: Lab5.c startup.s eFile.c ff.c loader.c
    ../RTOS/: ADC.c heap.c Interpreter.c OS.c ST7735.c UART0int.c osasm_keil.s eDisk.c
    ../utils/: bit-utils.c str-utils.c uart-utils.c
    ../vware/: PLL.c ADCT0ATrigger.c IRDistance.c LPF.c
  group Drivers
    ../drivers/: gpio.c interrupt.c launchpad.c timers.c gpio.h interrupt.h launchpad.h timers.h
software components: CMSIS:CORE 5.0.2
